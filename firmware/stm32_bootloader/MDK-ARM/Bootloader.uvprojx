# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xB,__MICROLIB,M2_BOOT,M2_UART_UPDATE
  c misc: -Oz -Wall
  c include: ../../stm32_app/Core/Inc;../../stm32_app/Drivers/STM32F1xx_HAL_Driver/Inc;../../stm32_app/Drivers/CMSIS/Include;../../stm32_app/Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../protocol;..
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ../boot.sct
  group SmartCar sources
    ../../stm32_app/MDK-ARM/: startup_stm32f103xb.s
    ../: main.c uart_service.c boot_guard.c ota_receiver.c update_request.c stm32_flash.c
    ../../../protocol/: car_protocol.c
    ../../stm32_app/Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.0.1
