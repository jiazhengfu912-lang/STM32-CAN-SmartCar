# Keil uVision project SmartCar.uvprojx, settings and files
target SmartCar (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08004000,0xB800) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: SmartCar +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,__MICROLIB
  c misc: -Oz -Wall
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../protocol;../../stm32_bootloader
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ./app.sct
  group SmartCar sources
    ./: startup_stm32f103xb.s
    ../Core/Src/: angle_speed.c drive.c imu.c main.c mpu6050.c navigation.c smartcar.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_can.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c
    ../../../protocol/: car_protocol.c
    ../../stm32_bootloader/: update_request.c ota_receiver.c
software components: CMSIS:CORE 5.0.1
